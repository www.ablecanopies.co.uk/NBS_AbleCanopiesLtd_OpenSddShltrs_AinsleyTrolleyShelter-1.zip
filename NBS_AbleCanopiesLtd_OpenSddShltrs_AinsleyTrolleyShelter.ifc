Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-05-04T16:29:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Mon May 04 16:29:37 2020* Host: NCL-PI19* Database: C:\Users\MatukiNE\AppData\Local\Temp\{D3C1045C-CAA5-4E4E-90AA-4BD12F412744}\ifc* Database version: 5507* Database creation date: Mon May 04 16:29:37 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Mon May 04 16:29:37 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Mon May 04 16:29:37 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: MelburyTrolleyShelter, NBS_AbleCanopiesLtd_OpenSddShltrs_AinsleyTrolleyShelter:MelburyTrolleyShelter:16898
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_20_65_78_58 (Uniclass2015); Material: NBS_Concept, NBS_Plastic_Clear
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AbleCanopiesLtd_OpenSidedShelters_AinsleyTrolleyShelter; ManufacturerName: Able Canopies Ltd; ManufacturerURL: www.ablecanopies.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/xadrizxq; NBSDescription: Open sided shelters; NBSReference: 45-05-75/315; ProductInformation: https://www.ablecanopies.co.uk/shelters/shopping-trolley-shelters/melbury-trolley-shelter.html; Revision: n/a; Uniclass2015Title: Open sided shelters; Uniclass2015Code: Pr_20_65_78_58; Uniclass2015Version: Products v1.17; Version: 4
Type - NBS_Data - FrameMaterial: NBS_Concept; FrameFinish: Powder coated; FrameColour: Any RAL colours; RoofCovering: 8 mm laminated safety glass; OpeningsDoors: n/a; OpeningsWindows: n/a; OpeningsRoofVents: n/a; IntegralServices: Guttering; RainwaterDrainage: A guttering system is hidden within the shelter frame and posts; Accessories: Cycle racks; Benches; Visibility stickers & Front glass panels; Panels: 8 mm toughened safety glass; Guttering: Integrated; WeatherResistance: n/a
Type - Pset_FurnitureTypeCommon - NominalDepth: 0 mm; NominalLength: 0 mm; Description: n/a; MainColor: n/a; NominalHeight: 2300 mm; Style: Shelter
Type - IFC - IfcExportAs: IfcBuildingElementProxyType; IfcExportType: USERDEFINED
Type - COBie - NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_65_78_58; Open sided shelters; CodePerformance: n/a; Color: www.ablecanopies.co.uk/colours-finishes.html; Constituents: n/a; DurationUnit: year; ExpectedLife: 25 years; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: sales@ablecanopies.co.uk; Material: n/a; ModelNumber: n/a; ModelReference: Ainsley Trolley Shelter; Name: OpenSidedShelters_AinsleyTrolleyShelter_AbleCanopiesLtd; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: 2 year (frame); WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
BOS_General - BIMObjectName: NBS_AbleCanopiesLtd_OpenSidedShelters_MelburyTrolleyShelter
COBie - Category: Generic Models; ModelReference: Melbury Trolley Shelter; Name: OpenSidedShelters_MelburyTrolleyShelter_AbleCanopiesLtd; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
